/**
  ******************************************************************************
  * 文件名程: 
  * 作    者: 浩盛科技
  * 版    本: V1.0
  * 编写日期: 
  * 功    能: 
  ******************************************************************************
  */
/* 包含头文件 ----------------------------------------------------------------*/

#include "pid_drv.h"                                  

/**
 * 函数功能: PID控制（抗积分饱和）
 * 输入参数: p - pid_struct结构体指针，包含比例系数kp、积分系数ki、微分系数kd，
 *          目标值ref、反馈值fbk、输出上下限out_max/out_min、积分累加integrate等
 * 返回参数: 无（计算结果存入p->out）
 * 说    明: 
 *         1. 采用位置式PID算法，计算公式：
 *            out = kp * err + integrate + kd * (err - err_last)
 *         2. 抗积分饱和策略：
 *            只有当输出未达到限幅值（out_min < out < out_max）时，才累加积分项。
 *            如果输出已经饱和，则停止积分累加，防止积分过深导致退出饱和时响应滞后。
 *         3. 误差计算：err = ref - fbk（可适应正反向调节）
 *         4. 微分项使用当前误差与上次误差之差，实现不完全微分（未滤波）。
 *         5. 输出限幅：最终out被限制在[out_min, out_max]范围内，确保控制量不超限。
 *         6. 该PID适用于电机控制中的电流环、速度环、位置环等。
 */
void pid_control(pid_struct *p)
{
    p->err = p->ref - p->fbk;                           // 计算当前误差

    // 抗积分饱和：只有输出未饱和时才累加积分项
    if (p->out < p->out_max && p->out > p->out_min)
    {
        p->integrate = p->integrate + p->ki * p->err;   // 积分累加（ki已包含采样时间）
    }

    // 计算PID输出（比例+积分+微分）
    p->out = p->kp * p->err +                           // 比例项
             p->integrate +                             // 积分项
             p->kd * (p->err - p->err_last);            // 微分项

    // 输出上限幅
    if (p->out >= p->out_max)
    {
        p->out = p->out_max;
    }
    // 输出下限幅
    if (p->out <= p->out_min)
    {
        p->out = p->out_min;
    }

    p->err_last = p->err;                               // 保存本次误差供下次微分使用
}

/**
 * 函数功能: 重置PID所有相关变量为零
 * 输入参数: p - pid_struct结构体指针
 * 返回参数: 无
 * 说    明: 
 *         将PID控制器的目标值、反馈值、输出值、误差值、上次误差、积分项全部清零。
 *         通常在电机启动前、模式切换时或参数重新整定前调用，避免历史数据干扰新的控制过程。
 *         注意：该函数不改变PID的kp、ki、kd、输出限幅等配置参数，仅重置运行状态变量。
 */
void pid_clear(pid_struct *p)
{
    p->ref = 0;       // 重置目标值
    p->fbk = 0;       // 重置反馈值
    p->out = 0;       // 重置输出值
    p->err = 0;       // 重置误差值
    p->err_last = 0;  // 重置上次误差值
    p->integrate = 0; // 重置积分累加项
}



